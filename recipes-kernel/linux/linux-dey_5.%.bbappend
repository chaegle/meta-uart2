FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-ccimx6ulstarter-dts-enable-uart2-disable-ecspi3.patch"

